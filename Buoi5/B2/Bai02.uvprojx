# Keil uVision project Bai02.uvprojx, settings and files
target Bai02 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bai02 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\inc;..\..\common\config;..\..\common\FreeRTOS\include;..\..\common\platform\cmsis\core;..\..\common\platform\cmsis\device;..\..\common\platform\StdPeriph_Driver\inc;..\..\..\..\FreeRTOS-Kernel-11.3.1\FreeRTOS-Kernel-11.3.1\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../common/platform/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../common/platform/cmsis/device/: system_stm32f10x.c
  group StdPeriph_Driver
    ../../common/platform/StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c
  group FreeRTOS
    ../../common/FreeRTOS/: tasks.c queue.c list.c
    ../../common/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../FreeRTOS-Kernel-11.3.1/FreeRTOS-Kernel-11.3.1/portable/RVDS/ARM_CM3/: port.c
  group App
    ../src/: main.c app_tasks.c bsp.c
    ../inc/: app.h bsp.h
    ../../common/config/: FreeRTOSConfig.h
